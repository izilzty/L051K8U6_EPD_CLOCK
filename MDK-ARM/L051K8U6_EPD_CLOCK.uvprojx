# Keil uVision project L051K8U6_EPD_CLOCK.uvprojx, settings and files
target L051K8U6_EPD_CLOCK (6140000::V6.14::ARMCLANG)
  device: STM32L051K8Ux STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: L051K8U6_EPD_CLOCK +hex
  c flags: Optim=6 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=8000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,MSI_VALUE=2097000,HSI_VALUE=16000000,LSI_VALUE=37000,VDD_VALUE=3300,PREFETCH_ENABLE=0,INSTRUCTION_CACHE_ENABLE=1,DATA_CACHE_ENABLE=1,STM32L051xx
  c include: ../Inc;  ../Drivers/STM32L0xx_HAL_Driver/Inc;  ../Drivers/CMSIS/Device/ST/STM32L0xx/Include;  ../Drivers/CMSIS/Include;  ../Src/USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32l051xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c i2c.c spi.c tim.c usart.c stm32l0xx_it.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_ll_gpio.c stm32l0xx_ll_adc.c stm32l0xx_ll_dma.c stm32l0xx_ll_rcc.c stm32l0xx_ll_utils.c stm32l0xx_ll_exti.c stm32l0xx_ll_i2c.c stm32l0xx_ll_spi.c stm32l0xx_ll_pwr.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group USER
    ../Src/USER/: eeprom.c func.c serial.c bkpr.c iic.c lowpower.c ds3231.c gdeh029a1.c
software components: CMSIS:CORE 5.4.0
